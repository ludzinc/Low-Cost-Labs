# IAR project STMBLINK.ewp, settings and files
configuration Release (STM8)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STMBLINK.bin
  ILINK.IlinkOutputFile: STMBLINK.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.c
